# Keil uVision project temperature_text.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temperature_text +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS;..\User;..\BSP\I2C;..\Library\STM32F10x_StdPeriph_Driver\inc;..\User\delay;..\User\sys;..\User\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Library/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c
    ../User/delay/: delay.c
    ../User/sys/: sys.c
    ../User/USART/: bsp_usart.c
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h
  group DOC
    ../Doc/: readme.txt
  group FWLIB
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/I2C/: bsp_i2c_temperature.c
